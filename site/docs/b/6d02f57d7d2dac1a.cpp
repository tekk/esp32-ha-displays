/*
 * Minimal, self-contained ES8389 codec driver for Arduino / ESP32.
 * See ES8389.h for details. Register sequence ported from the Espressif
 * ES8389 reference driver (JC1060F570 factory demo).
 */

#include "ES8389.h"

// ---------------------------------------------------------------------------
// Clock coefficient table (from the Espressif ES8389 reference driver).
// Columns: ratio, MCLK(Hz), LRCK(Hz), then the codec registers that must be
// written for that combination. The order of the register fields matches the
// comment in the reference source.
// ---------------------------------------------------------------------------
struct CoeffDiv {
    uint16_t ratio;
    uint32_t mclk;
    uint32_t lrck;
    uint8_t r04, r05, r06, r07, r08, r09, r0a, r0f, r11;
    uint8_t r21, r22, r26, r30, r41, r42, r43, rF0, rF1;
    uint8_t r16, r18, r19;
};

static const CoeffDiv coeff_div[] = {
    {32,256000,8000,0x00,0x57,0x84,0xD0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {36,288000,8000,0x00,0x55,0x84,0xD0,0x01,0xC1,0x90,0x00,0x00,0x23,0x8F,0xB7,0xC0,0x1F,0x8F,0x01,0x12,0x00,0x09,0x19,0x07},
    {48,384000,8000,0x02,0x5F,0x04,0xC0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {64,512000,8000,0x00,0x4D,0x24,0xC0,0x03,0xD1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {72,576000,8000,0x00,0x45,0x24,0xC0,0x01,0xD1,0x90,0x00,0x00,0x23,0x8F,0xB7,0xC0,0x1F,0x8F,0x01,0x12,0x00,0x09,0x19,0x07},
    {96,768000,8000,0x02,0x57,0x84,0xD0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {128,1024000,8000,0x00,0x45,0x04,0xD0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {192,1536000,8000,0x02,0x4D,0x24,0xC0,0x03,0xD1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {256,2048000,8000,0x01,0x45,0x04,0xD0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {288,2304000,8000,0x01,0x51,0x00,0xC0,0x01,0xC1,0x90,0x00,0x00,0x23,0x8F,0xB7,0xC0,0x1F,0x8F,0x01,0x12,0x00,0x09,0x19,0x07},
    {384,3072000,8000,0x02,0x45,0x04,0xD0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {512,4096000,8000,0x00,0x41,0x04,0xE0,0x00,0xD1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {768,6144000,8000,0x05,0x45,0x04,0xD0,0x03,0xC1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {1024,8192000,8000,0x01,0x41,0x06,0xE0,0x00,0xD1,0xB0,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {1536,12288000,8000,0x02,0x41,0x04,0xE0,0x00,0xD1,0xB0,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {1625,13000000,8000,0x40,0x6E,0x05,0xC8,0x01,0xC2,0x90,0x40,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x09,0x19,0x07},
    {2048,16384000,8000,0x03,0x44,0x01,0xC0,0x00,0xD2,0x80,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {2304,18432000,8000,0x11,0x45,0x25,0xF0,0x00,0xD1,0xB0,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {3072,24576000,8000,0x05,0x44,0x01,0xC0,0x00,0xD2,0x80,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x01,0x12,0x00,0x09,0x19,0x07},
    {32,512000,16000,0x00,0x55,0x84,0xD0,0x01,0xC1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {36,576000,16000,0x00,0x55,0x84,0xD0,0x01,0xC1,0x90,0x00,0x00,0x23,0x8F,0xB7,0xC0,0x1F,0x8F,0x01,0x12,0x00,0x12,0x31,0x0E},
    {48,768000,16000,0x02,0x57,0x04,0xC0,0x01,0xC1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {50,800000,16000,0x00,0x7E,0x01,0xD9,0x00,0xC2,0x80,0x00,0x00,0x18,0x95,0xD0,0xC0,0xC7,0x95,0x00,0x12,0x00,0x12,0x31,0x0E},
    {64,1024000,16000,0x00,0x45,0x24,0xC0,0x01,0xD1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {72,1152000,16000,0x00,0x45,0x24,0xC0,0x01,0xD1,0x90,0x00,0x00,0x23,0x8F,0xB7,0xC0,0x1F,0x8F,0x01,0x12,0x00,0x12,0x31,0x0E},
    {96,1536000,16000,0x02,0x55,0x84,0xD0,0x01,0xC1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {128,2048000,16000,0x00,0x51,0x04,0xD0,0x01,0xC1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {144,2304000,16000,0x00,0x51,0x00,0xC0,0x01,0xC1,0x90,0x00,0x00,0x23,0x8F,0xB7,0xC0,0x1F,0x8F,0x01,0x12,0x00,0x12,0x31,0x0E},
    {192,3072000,16000,0x02,0x65,0x25,0xE0,0x00,0xE1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {256,4096000,16000,0x00,0x41,0x04,0xC0,0x01,0xD1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {300,4800000,16000,0x02,0x66,0x01,0xD9,0x00,0xC2,0x80,0x00,0x00,0x18,0x95,0xD0,0xC0,0xC7,0x95,0x00,0x12,0x00,0x12,0x31,0x0E},
    {384,6144000,16000,0x02,0x51,0x04,0xD0,0x01,0xC1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {512,8192000,16000,0x01,0x41,0x04,0xC0,0x01,0xD1,0x90,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {750,12000000,16000,0x0E,0x7E,0x01,0xC9,0x00,0xC2,0x80,0x40,0x00,0x18,0x95,0xD0,0xC0,0xC7,0x95,0x00,0x12,0x00,0x12,0x31,0x0E},
    {768,12288000,16000,0x02,0x41,0x04,0xC0,0x01,0xD1,0x90,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {1024,16384000,16000,0x03,0x41,0x04,0xC0,0x01,0xD1,0x90,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {1152,18432000,16000,0x08,0x51,0x04,0xD0,0x01,0xC1,0x90,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {1200,19200000,16000,0x0B,0x66,0x01,0xD9,0x00,0xC2,0x80,0x40,0x00,0x18,0x95,0xD0,0xC0,0xC7,0x95,0x00,0x12,0x00,0x12,0x31,0x0E},
    {1500,24000000,16000,0x0E,0x26,0x01,0xD9,0x00,0xC2,0x80,0xC0,0x00,0x18,0x95,0xD0,0xC0,0xC7,0x95,0x00,0x12,0x00,0x12,0x31,0x0E},
    {1536,24576000,16000,0x05,0x41,0x04,0xC0,0x01,0xD1,0x90,0xC0,0x00,0x1F,0x7F,0xBF,0xC0,0xFF,0x7F,0x00,0x12,0x00,0x12,0x31,0x0E},
    {1625,26000000,16000,0x40,0x6E,0x05,0xC8,0x01,0xC2,0x90,0xC0,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x12,0x31,0x0E},
    {800,19200000,24000,0x07,0x66,0x01,0xD9,0x00,0xC2,0x80,0x40,0x00,0x18,0x95,0xD0,0xC0,0xC7,0x95,0x00,0x12,0x00,0x1A,0x49,0x14},
    {600,19200000,32000,0x05,0x46,0x01,0xD8,0x10,0xD2,0x80,0x40,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x23,0x61,0x1B},
    {32,1411200,44100,0x00,0x45,0xA4,0xD0,0x10,0xD1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {64,2822400,44100,0x00,0x51,0x00,0xC0,0x10,0xC1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {128,5644800,44100,0x00,0x41,0x04,0xD0,0x10,0xD1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {256,11289600,44100,0x01,0x41,0x04,0xD0,0x10,0xD1,0x80,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {512,22579200,44100,0x03,0x41,0x04,0xD0,0x10,0xD1,0x80,0xC0,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {32,1536000,48000,0x00,0x45,0xA4,0xD0,0x10,0xD1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {48,2304000,48000,0x02,0x55,0x04,0xC0,0x10,0xC1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {50,2400000,48000,0x00,0x76,0x01,0xC8,0x10,0xC2,0x80,0x00,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {64,3072000,48000,0x00,0x51,0x04,0xC0,0x10,0xC1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {100,4800000,48000,0x00,0x46,0x01,0xD8,0x10,0xD2,0x80,0x00,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {125,6000000,48000,0x04,0x6E,0x05,0xC8,0x10,0xC2,0x80,0x00,0x01,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {128,6144000,48000,0x00,0x41,0x04,0xD0,0x10,0xD1,0x80,0x00,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {200,9600000,48000,0x01,0x46,0x01,0xD8,0x10,0xD2,0x80,0x00,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {250,12000000,48000,0x04,0x76,0x01,0xC8,0x10,0xC2,0x80,0x40,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {256,12288000,48000,0x01,0x41,0x04,0xD0,0x10,0xD1,0x80,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {384,18432000,48000,0x02,0x41,0x04,0xD0,0x10,0xD1,0x80,0x40,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {400,19200000,48000,0x03,0x46,0x01,0xD8,0x10,0xD2,0x80,0x40,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {500,24000000,48000,0x04,0x46,0x01,0xD8,0x10,0xD2,0x80,0xC0,0x00,0x18,0x95,0xD0,0xC0,0x63,0x95,0x00,0x12,0x00,0x35,0x91,0x28},
    {512,24576000,48000,0x03,0x41,0x04,0xD0,0x10,0xD1,0x80,0xC0,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {800,38400000,48000,0x18,0x45,0x04,0xC0,0x10,0xC1,0x80,0xC0,0x00,0x1F,0x7F,0xBF,0xC0,0x7F,0x7F,0x00,0x12,0x00,0x35,0x91,0x28},
    {128,11289600,88200,0x00,0x50,0x00,0xC0,0x10,0xC1,0x80,0x40,0x00,0x9F,0x7F,0xBF,0xC0,0x7F,0x7F,0x80,0x12,0xC0,0x32,0x89,0x25},
    {64,6144000,96000,0x00,0x41,0x00,0xD0,0x10,0xD1,0x80,0x00,0x00,0x9F,0x7F,0xBF,0xC0,0x7F,0x7F,0x80,0x12,0xC0,0x35,0x91,0x28},
    {256,24576000,96000,0x00,0x40,0x00,0xC0,0x10,0xC1,0x80,0xC0,0x00,0x9F,0x7F,0xBF,0xC0,0x7F,0x7F,0x80,0x12,0xC0,0x35,0x91,0x28},
    {128,24576000,192000,0x00,0x50,0x00,0xC0,0x18,0xC1,0x81,0xC0,0x00,0x8F,0x7F,0xEF,0xC0,0x3F,0x7F,0x80,0x12,0xC0,0x3F,0xF9,0x3F},
    {50,400000,8000,0x00,0x75,0x05,0xC8,0x01,0xC1,0x90,0x10,0x00,0x18,0xC7,0xD0,0xC0,0x8F,0xC7,0x01,0x12,0x00,0x09,0x19,0x07},
    {600,4800000,8000,0x05,0x65,0x25,0xF9,0x00,0xD1,0x90,0x10,0x00,0x18,0xC7,0xD0,0xC0,0x8F,0xC7,0x01,0x12,0x00,0x09,0x19,0x07},
    {1500,12000000,8000,0x0E,0x25,0x25,0xE8,0x00,0xD1,0x90,0x40,0x00,0x31,0xC7,0xC5,0x00,0x8F,0xC7,0x01,0x12,0x00,0x09,0x19,0x07},
    {2400,19200000,8000,0x0B,0x01,0x00,0xD0,0x00,0xD1,0x80,0x90,0x00,0x31,0xC7,0xC5,0x00,0xC7,0xC7,0x00,0x12,0x00,0x09,0x19,0x07},
    {3000,24000000,8000,0x0E,0x24,0x05,0xD0,0x00,0xC2,0x80,0xC0,0x00,0x31,0xC7,0xC5,0x00,0x8F,0xC7,0x01,0x12,0x00,0x09,0x19,0x07},
    {3250,26000000,8000,0x40,0x05,0xA4,0xC0,0x00,0xD1,0x80,0xD0,0x00,0x31,0xC7,0xC5,0x00,0xC7,0xC7,0x00,0x12,0x00,0x09,0x19,0x07},
};

// ---------------------------------------------------------------------------

ES8389::ES8389() : _wire(nullptr), _addr(0x10), _open(false),
                   _useMclk(false), _noDacRef(false) {}

bool ES8389::begin(uint8_t addr, int sda, int scl) {
    _addr    = addr;
    _useMclk = false;     // JC1060F570: no MCLK pin
    _noDacRef = false;    // internal DAC reference enabled
    _wire = &Wire;

    // This board relies on (internal) pull-ups; 400 kHz is easily too fast for
    // them, which shows up as "reads 0xFF / no ACK". 100 kHz is much safer.
    _wire->begin(sda, scl);
    _wire->setClock(100000);

    // ---- Diagnostic: scan the whole bus so the serial log shows what is there ----
    Serial.printf("ES8389: scanning I2C (SDA=%d, SCL=%d) ...\n", sda, scl);
    int found = 0;
    for (uint8_t a = 0x08; a < 0x78; a++) {
        if (probeAddr(a)) {
            Serial.printf("  found I2C device at 0x%02X\n", a);
            found++;
        }
    }
    if (found == 0) {
        Serial.println("ES8389: NO I2C device responded (check SDA/SCL/wiring)");
        return false;
    }

    // ---- Confirm the configured address, otherwise try a few common ones ----
    if (!probeAddr(_addr)) {
        Serial.printf("ES8389: 0x%02X did not ACK, trying alternates ...\n", _addr);
        static const uint8_t alts[] = {0x11, 0x20, 0x21, 0x18, 0x19, 0x10};
        bool ok = false;
        for (uint8_t i = 0; i < sizeof(alts); i++) {
            if (alts[i] != _addr && probeAddr(alts[i])) {
                _addr = alts[i];
                ok = true;
                Serial.printf("ES8389: using alternate address 0x%02X\n", _addr);
                break;
            }
        }
        if (!ok) {
            Serial.println("ES8389: codec address not found");
            return false;
        }
    }

    // Chip ID registers 0xFD/0xFE (ES8389 should read 0x83/0x89).
    uint8_t id1 = readReg(ES8389_CHIP_ID1_CONTROL_REG0xFD);
    uint8_t id2 = readReg(ES8389_CHIP_ID2_CONTROL_REG0xFE);
    Serial.printf("ES8389: chip ID = 0x%02X 0x%02X\n", id1, id2);

    openCodec();
    startBias();
    setVolume(0xBF); // sane default, overridden later by the app
    Serial.println("ES8389 initialized");
    return true;
}

bool ES8389::probeAddr(uint8_t a) {
    _wire->beginTransmission(a);
    return _wire->endTransmission() == 0;
}

void ES8389::writeReg(uint8_t reg, uint8_t val) {
    _wire->beginTransmission(_addr);
    _wire->write(reg);
    _wire->write(val);
    _wire->endTransmission();
}

uint8_t ES8389::readReg(uint8_t reg) {
    _wire->beginTransmission(_addr);
    _wire->write(reg);
    _wire->endTransmission(false);
    _wire->requestFrom((int)_addr, 1);
    return _wire->available() ? (uint8_t)_wire->read() : 0;
}

void ES8389::updateBits(uint8_t reg, uint8_t mask, uint8_t val) {
    uint8_t regval = readReg(reg);
    regval &= ~mask;
    regval |= (val & mask);
    writeReg(reg, regval);
}

void ES8389::openCodec() {
    writeReg(ES8389_ISOLATION_CONTROL_REG0xF3, 0x00);
    writeReg(ES8389_RESET_REG0x00, 0x7E);
    writeReg(ES8389_ISOLATION_CONTROL_REG0xF3, 0x38);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x24, 0x64);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x25, 0x04);
    writeReg(ES8389_DAC_CONTROL_REG0x45, 0x03);
    writeReg(ES8389_VMID_CONTROL_REG0x60, 0x2A);
    writeReg(ES8389_ANALOG_CONTROL_REG0x61, 0xC9);
    writeReg(ES8389_ANALOG_CONTROL_REG0x62, 0x4F);
    writeReg(ES8389_ANALOG_CONTROL_REG0x63, 0x06);
    writeReg(ES8389_ANALOG_CONTROL_REG0x6B, 0x00);
    writeReg(ES8389_ANALOG_CONTROL_REG0x6D, 0x16);
    writeReg(ES8389_ANALOG_CONTROL_REG0x6E, 0xAA);
    writeReg(ES8389_ANALOG_CONTROL_REG0x6F, 0x66);
    writeReg(ES8389_ANALOG_CONTROL_REG0x70, 0x99);

    writeReg(ES8389_ADC_SP_CONTROL_REG0x23, 0x00);
    writeReg(ES8389_PGA1_GAIN_CONTROL_REG0x72, (uint8_t)((ES8389_ADCL_InputSel << 4) + 0));
    writeReg(ES8389_PGA1_GAIN_CONTROL_REG0x73, (uint8_t)((ES8389_ADCR_InputSel << 4) + 0));
    writeReg(ES8389_CLK_MANAGER_REG0x10, 0xC4);
    writeReg(ES8389_MISC_CONTROL_REG0x01, 0x08);
    writeReg(ES8389_CSM_STATE_REG0xF1, 0x00);
    writeReg(0x12, 0x01);
    writeReg(0x13, 0x01);
    writeReg(0x14, 0x01);
    writeReg(0x15, 0x01);
    writeReg(0x16, 0x35);
    writeReg(0x17, 0x09);
    writeReg(0x18, 0x91);
    writeReg(0x19, 0x28);
    writeReg(0x1A, 0x01);
    writeReg(0x1B, 0x01);
    writeReg(0x1C, 0x11);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x2A, 0x00);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x20, (uint8_t)(ES8389_S16_LE + ES8389_DAIFMT_I2S));
    writeReg(ES8389_DAC_CONTROL_REG0x40, (uint8_t)(ES8389_S16_LE + ES8389_DAIFMT_I2S));
    writeReg(ES8389_CHIP_MISC_CONTROL_REG0xF0, 0x01);
    writeReg(ES8389_CLK_MANAGER_REG0x02, 0x00);
    writeReg(ES8389_CLK_MANAGER_REG0x04, 0x00);
    writeReg(ES8389_CLK_MANAGER_REG0x05, 0x10);
    writeReg(ES8389_CLK_MANAGER_REG0x06, 0x00);
    writeReg(ES8389_CLK_MANAGER_REG0x07, 0xC0);
    writeReg(ES8389_CLK_MANAGER_REG0x08, 0x00);
    writeReg(ES8389_CLK_MANAGER_REG0x09, 0xC0);
    writeReg(ES8389_CLK_MANAGER_REG0x0A, 0x80);
    writeReg(ES8389_CLK_MANAGER_REG0x0B, 4);
    writeReg(ES8389_CLK_MANAGER_REG0x0C, (uint8_t)(256 >> 8));
    writeReg(ES8389_CLK_MANAGER_REG0x0D, (uint8_t)(256 & 0xFF));
    writeReg(ES8389_CLK_MANAGER_REG0x0F, 0x10);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x21, 0x1F);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x22, 0x7F);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x2F, 0xC0);
    writeReg(0x30, 0xF4);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x31, 0x00);
    writeReg(ES8389_DAC_CONTROL_REG0x44, 0x00);
    writeReg(ES8389_DAC_CONTROL_REG0x41, 0x7F);
    writeReg(ES8389_DAC_CONTROL_REG0x42, 0x7F);
    writeReg(ES8389_DAC_CONTROL_REG0x43, 0x10);
    writeReg(ES8389_DAC_CONTROL_REG0x49, 0x0F);
    writeReg(0x4C, 0xC0);

    writeReg(ES8389_RESET_REG0x00, 0x00);
    writeReg(ES8389_CLK_MANAGER_REG0x03, 0xC1);
    writeReg(ES8389_RESET_REG0x00, 0x01);
    writeReg(ES8389_DAC_CONTROL_REG0x4D, 0x00);

    writeReg(ES8389_ADC_SP_CONTROL_REG0x26, 191);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x27, 191);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x28, 191);
    writeReg(ES8389_DAC_CONTROL_REG0x46, 191);
    writeReg(ES8389_DAC_CONTROL_REG0x47, 191);
    writeReg(ES8389_DAC_CONTROL_REG0x48, (uint8_t)(95 << 1));

    // Codec is I2S SLAVE
    updateBits(ES8389_MISC_CONTROL_REG0x01, ES8389_MASK_MSModeSel, 0);
    // No MCLK pin: select internal MCLK source
    updateBits(ES8389_CLK_MANAGER_REG0x02, 0xC0, 1 << 6);
    updateBits(ES8389_CLK_MANAGER_REG0x02, 0x02, 0);   // MCLK not inverted
    // Internal DAC reference enabled
    updateBits(ES8389_ADC_SP_CONTROL_REG0x23, 0x80, 0x80);
    writeReg(ES8389_CHIP_MISC_CONTROL_REG0xF0, (uint8_t)(0x12 + (1 << 3)));
    updateBits(ES8389_CLK_MANAGER_REG0x02, 0x01, 0);   // SCLK not inverted

    _open = true;
}

void ES8389::startBias() {
    writeReg(ES8389_DAC_CONTROL_REG0x4D, 0x00);
    updateBits(ES8389_ANALOG_CONTROL_REG0x69, 0x20, 0x20);
    writeReg(ES8389_ANALOG_CONTROL_REG0x61, 0xD9);
    writeReg(ES8389_ANALOG_CONTROL_REG0x64, 0x8F);
    writeReg(ES8389_CLK_MANAGER_REG0x10, 0xE4);
    writeReg(ES8389_RESET_REG0x00, 0x01);
    writeReg(ES8389_CLK_MANAGER_REG0x03, 0xC3);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x24, 0x6A);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x25, (uint8_t)(0x0A));
}

void ES8389::setBitsPerSample(uint8_t bits) {
    uint8_t state = 0;
    switch (bits) {
        case 18: state = ES8389_S18_LE; break;
        case 20: state = ES8389_S20_LE; break;
        case 24: state = ES8389_S24_LE; break;
        case 32: state = ES8389_S32_LE; break;
        case 16:
        default: state = ES8389_S16_LE; break;
    }
    updateBits(ES8389_ADC_SP_CONTROL_REG0x20, ES8389_MASK_DATALEN, state);
    updateBits(ES8389_DAC_CONTROL_REG0x40, ES8389_MASK_DATALEN, state);
}

void ES8389::configFmt() {
    updateBits(ES8389_CLK_MANAGER_REG0x0C, 0xE0, 0x00); // I2S normal
    updateBits(ES8389_ADC_SP_CONTROL_REG0x20, ES8389_MASK_DAIFMT, ES8389_DAIFMT_I2S);
    updateBits(ES8389_DAC_CONTROL_REG0x40, ES8389_MASK_DAIFMT, ES8389_DAIFMT_I2S);
}

int ES8389::findCoeff(uint32_t mclk, uint32_t rate) {
    for (int i = 0; i < (int)(sizeof(coeff_div) / sizeof(coeff_div[0])); i++) {
        if (coeff_div[i].ratio == rate && coeff_div[i].mclk == mclk) {
            return i;
        }
    }
    return -1;
}

void ES8389::configSample(uint32_t sr, uint8_t bits) {
    uint32_t mclk_fre = (uint32_t)sr * bits * (_noDacRef ? 2 : 4);
    uint32_t rate = mclk_fre / sr;
    int coeff = findCoeff(mclk_fre, rate);
    if (coeff < 0) {
        Serial.printf("ES8389: no clock coeff for %u Hz (mclk=%u)\r\n", sr, mclk_fre);
        return;
    }
    const CoeffDiv &c = coeff_div[coeff];
    writeReg(ES8389_CLK_MANAGER_REG0x04, c.r04);
    writeReg(ES8389_CLK_MANAGER_REG0x05, c.r05);
    writeReg(ES8389_CLK_MANAGER_REG0x06, c.r06);
    writeReg(ES8389_CLK_MANAGER_REG0x07, c.r07);
    writeReg(ES8389_CLK_MANAGER_REG0x08, c.r08);
    writeReg(ES8389_CLK_MANAGER_REG0x09, c.r09);
    writeReg(ES8389_CLK_MANAGER_REG0x0A, c.r0a);
    updateBits(ES8389_CLK_MANAGER_REG0x0F, 0xC0, c.r0f);
    writeReg(ES8389_CLK_MANAGER_REG0x11, c.r11);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x21, c.r21);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x22, c.r22);
    writeReg(ES8389_ADC_SP_CONTROL_REG0x26, c.r26);
    updateBits(0x30, 0xC0, c.r30);
    writeReg(ES8389_DAC_CONTROL_REG0x41, c.r41);
    writeReg(ES8389_DAC_CONTROL_REG0x42, c.r42);
    updateBits(ES8389_DAC_CONTROL_REG0x43, 0x81, c.r43);
    updateBits(ES8389_CHIP_MISC_CONTROL_REG0xF0, 0x73, c.rF0);
    writeReg(ES8389_CSM_STATE_REG0xF1, c.rF1);
    writeReg(0x16, c.r16);
    writeReg(0x18, c.r18);
    writeReg(0x19, c.r19);
}

bool ES8389::configure(uint32_t sampleRate, uint8_t bits) {
    if (!_open) return false;
    if (!_useMclk) {
        configSample(sampleRate, bits);
    }
    setBitsPerSample(bits);
    configFmt();
    return true;
}

void ES8389::setVolume(uint8_t vol) {
    writeReg(ES8389_DAC_CONTROL_REG0x46, vol);
    writeReg(ES8389_DAC_CONTROL_REG0x47, vol);
}

void ES8389::mute(bool m) {
    uint8_t regv = readReg(ES8389_ADC_SP_CONTROL_REG0x20);
    regv &= 0xFC;
    if (m) regv |= 0x03;
    writeReg(ES8389_ADC_SP_CONTROL_REG0x20, regv);
}

void ES8389::enable(bool on) {
    if (on) {
        startBias();
    }
    // on=false: leaving the codec powered is acceptable for playback use.
}
